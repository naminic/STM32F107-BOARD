# Keil uVision project rtc.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtc +hex
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS Liberary\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: startup_stm32f10x_cl.s
  group main
    ./: main.c bsp.c
  group cmsis core
    ../../CMSIS Liberary/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS Liberary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group cmsis driver
    ../../CMSIS Liberary/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_pwr.c
