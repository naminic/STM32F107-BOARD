# Keil uVision project DefaultProject.uvprojx, settings and files
target STM32F107VC (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DefaultProject +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: .\Delay;.\CMSIS_Liberary\CMSIS\CM3\CoreSupport;.\CMSIS_Liberary\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS_Liberary\STM32F10x_StdPeriph_Driver\inc;.\net_lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./CMSIS_Liberary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group CM3
    ./CMSIS_Liberary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Utility
    ./Delay/: delay.c
  group Abstract
    ./Abstract/: Abstract.txt
  group Main
    ./Main/: main.c
  group net
    ./net_lib/: TCP_CM3.lib ETH_STM32x.c Net_Config.c
